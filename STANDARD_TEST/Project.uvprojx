# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\Hardware;.\STM32_USB_Device_Library;.\USB_DEVICE;.\STM32_USB_Device_Library\Class\HID\Inc;.\STM32_USB_Device_Library\Class\HID\Src;.\STM32_USB_Device_Library\Core\Inc;.\STM32_USB_Device_Library\Core\Src;.\USB_DEVICE\App;.\USB_DEVICE\Target;.\HAL_USB_Drivers\STM32F1xx_HAL_Driver\Inc;.\HAL_USB_Drivers\STM32F1xx_HAL_Driver\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h Delay.c Delay.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group USB_library
    ./STM32_USB_Device_Library/Class/HID/Inc/: usbd_hid.h
    ./STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ./STM32_USB_Device_Library/Core/Inc/: usbd_conf_template.h usbd_core.h usbd_ctlreq.h usbd_def.h usbd_desc_template.h usbd_ioreq.h
    ./STM32_USB_Device_Library/Core/Src/: usbd_conf_template.c usbd_core.c usbd_ctlreq.c usbd_desc_template.c usbd_ioreq.c
    ./USB_DEVICE/App/: usb_device.c usb_device.h usbd_desc.c usbd_desc.h
    ./USB_DEVICE/Target/: usbd_conf.c usbd_conf.h
    ./HAL_USB_Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c
    ./HAL_USB_Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_ll_usb.h
